# Keil uVision project Project.uvprojx, settings and files
target Lighting (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x28000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BlueNRG1_Lighting_Demo +hex
  AfterMake: fromelf.exe --bin .\Objects\BlueNRG1_Lighting_Demo.axf --output .\Objects\BlueNRG1_Lighting_Demo.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ,LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ,SMPS_INDUCTOR=SMPS_INDUCTOR_10uH,ENABLE_USART,BLUENRG1_DEVICE,DISABLE_TRACES
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\OTA\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\hal\inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc;..\..\..\..\..\..\Projects\BlueNRG-1\Applications\Lighting_Demo\Inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group Application/User
    ../../Src/: BlueNRG1_it.c hal.c main.c data.s appli_mesh.c appli_generic.c models_if.c appli_vendor.c appli_light.c appli_sensor.c
  group Drivers/BSP/SDK_Eval_BlueNRG1
    ../../../../../../Drivers/BSP/SDK_Eval_BlueNRG1/src/: LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c PWM_config.c PWM_handlers.c
  group Drivers/BlueNRG1_Periph_Driver
    ../../../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Middlewares/BlueNRG1/Bluetooth_LE
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/src/: stack_user_cfg.c
  group Middlewares/BlueNRG1/HAL
    ../../../../../../Middlewares/ST/BlueNRG1/hal/src/: clock.c gp_timer.c osal.c sleep.c context_switch.s miscutil.c fifo.c
  group Middlewares/Cryptographic_Library
    ../../../../../../Middlewares/ST/ST_Cryptolib/BNRG1/Lib/: libcrypto_V300_CM0.a
  group Middlewares/ST/ST_BLE_Mesh/PAL/BlueNRG1_2
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/PAL/BlueNRG1_2/: pal_nvm.c
  group Middlewares/ST/ST_BLE_Mesh/MeshModel
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Src/: generic.c vendor.c light.c common.c sensors.c
  group Middlewares/ST/ST_BLE_Mesh
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Src/: mesh_cfg.c
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Library/: libBlueNRG_Mesh_CM0.a
  group Output
    ./Listings/: BlueNRG1_Lighting_Demo.map
