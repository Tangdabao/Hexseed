<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>BlueNRG_Mesh_Lib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>Lighting_Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


