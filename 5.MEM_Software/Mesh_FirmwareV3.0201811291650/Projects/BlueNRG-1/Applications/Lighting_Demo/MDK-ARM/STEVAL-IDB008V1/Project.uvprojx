# Keil uVision project Project.uvprojx, settings and files
target Lighting (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BlueNRG2_Lighting_Demo +hex
  AfterMake: fromelf.exe --bin .\Objects\BlueNRG2_Lighting_Demo.axf --output .\Objects\BlueNRG2_Lighting_Demo.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ,LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ,SMPS_INDUCTOR=SMPS_INDUCTOR_10uH,BLUENRG2, BLUENRG2_DEVICE,ENABLE_USART
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\OTA\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\hal\inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc;..\..\..\..\..\..\Projects\BlueNRG-1\Applications\Lighting_Demo\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DST_OTA_LOWER_APPLICATION=1"
  group Application/User
    ../../Src/: BlueNRG1_it.c hal.c main.c data.s appli_mesh.c appli_generic.c models_if.c appli_vendor.c appli_light.c
  group Drivers/BSP/SDK_Eval_BlueNRG1
    ../../../../../../Drivers/BSP/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c PWM_config.c PWM_handlers.c SDK_EVAL_ADC.c
  group Drivers/BlueNRG1_Periph_Driver
    ../../../../../../Drivers/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Middlewares/BlueNRG1/Bluetooth_LE
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/library/: bluenrg1_stack_lib_keil.lib
  group Middlewares/BlueNRG1/HAL
    ../../../../../../Middlewares/ST/BlueNRG1/hal/src/: clock.c gp_timer.c osal.c sleep.c context_switch.s
  group Middlewares/ST/BLE_Mesh_Library
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Library/: libBlueNRG_Mesh_CM0.a
  group Middlewares/Cryptographic_Library
    ../../../../../../Middlewares/ST/ST_Cryptographic_Library/binary/EWARM/: iarCrypto_Cortex-M0_high-size_3_0_0.a
  group OTA
    ../../../../../../Middlewares/ST/BlueNRG1/Bluetooth_LE/OTA/src/: OTA_btl.c
  group Middlewares/ST/ST_BLE_Mesh/PAL/BlueNRG1_2
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/PAL/BlueNRG1_2/: pal_nvm.c
  group Middlewares/ST/ST_BLE_Mesh/MeshModel
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/MeshModel/Src/: generic.c vendor.c light.c common.c
  group Middlewares/ST/ST_BLE_Mesh
    ../../../../../../Middlewares/ST/ST_BLE_Mesh/Src/: mesh_cfg.c
target Lighting_OTA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BlueNRG2_OTA +hex
  AfterMake: fromelf.exe --bin .\Objects\BlueNRG2_OTA.axf --output .\Objects\BlueNRG2_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ,LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ,SMPS_INDUCTOR=SMPS_INDUCTOR_10uH,ENABLE_USART,BLUENRG2, BLUENRG2_DEVICE, ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\..\Drivers\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\..\Drivers\BSP\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\Bluetooth_LE\OTA\inc;..\..\..\..\..\..\Middlewares\ST\BlueNRG1\hal\inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\Inc;..\..\..\..\..\..\Middlewares\ST\ST_BLE_Mesh\MeshModel\Inc;..\..\..\..\..\..\Projects\BlueNRG-2\Applications\Lighting_Demo\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  link misc: --predefine="-DST_USE_OTA_SERVICE_MANAGER_APPLICATION=1"
