# Keil uVision project BLE_Throughput.uvprojx, settings and files
target Server_unidirectional (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_Throughput_Server_unidirectional +hex
  AfterMake: fromelf.exe --bin Server_unidirectional\Objects\BLE_Throughput_Server_unidirectional.axf --output Server_unidirectional\Objects\BLE_Throughput_Server_unidirectional.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 THROUGHPUT_TEST_SERVER UART_BAUDRATE=115200
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  link misc: --predefine="-DST_OTA_HIGHER_APPLICATION=1"
  group BlueNRG1_Periph_Driver
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Platforms_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Button.c SDK_EVAL_Led.c SDK_EVAL_ADC.c SDK_EVAL_Timer.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c gatt_db.c BLE_Throughput_main.c throughput.c
    ../../../../../Library/hal/src/: gp_timer.c
  group Hal
    ../../../../../Library/hal/src/: context_switch.s clock.c osal.c miscutil.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
    ../../../../../Library/cryptolib/: libcrypto.a
